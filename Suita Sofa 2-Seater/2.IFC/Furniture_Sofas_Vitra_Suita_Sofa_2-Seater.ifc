Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-06-19T17:06:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 19 17:06:44 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{963235D3-08C3-41CD-ABA1-4262F99B2AAB}\ifc * Database version: 5507 * Database creation date: Fri Jun 19 17:06:42 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 19 17:06:43 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 19 17:06:43 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Suita Sofa 2-Seater - Without Headrest, Furniture_Sofas_Vitra_Suita_Sofa_2seater:Suita Sofa 2-Seater - Without Headrest:337147
In: Level 1
Type - Material: Leather standard dimgrey 21, Aluminium polished 03
Type - Construction(Type) - ModelType: Suita_Classic_2seats
Type - General(Type) - Author: Convergo AB; BIMObjectName: Furniture_Sofas_Vitra_Suita_Sofa_2seater; ConvergoRefNr: 0089-2006-0004-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The Suita sofa system combines light and slender volumes with an industrial and technological aesthetic. The geometrically precise body and cushions seem to float above the sleek, bridge-like aluminium legs, in what can be seen as a tribute to mid-century American design. The Suita sofa family encompasses a wide range of components. These can be used as independent elements or freely combined to adapt to all kinds of interior environments and furnishing needs.; Revision: n/a; Uniclass2: Pr_40_50_12_81; Uniclass2015Description: Sofas; Uniclass2015Reference: Pr_40_50_12_81; Version: 1; VersionDate: 16/06/2020
Type - Identity Data(Type) - Collection: Suita; Cost: 0; Description: The Suita sofa system combines light and slender volumes with an industrial and technological aesthetic. The geometrically precise body and cushions seem to float above the sleek, bridge-like aluminium legs, in what can be seen as a tribute to mid-century American design. The Suita sofa family encompasses a wide range of components. These can be used as independent elements or freely combined to adapt to all kinds of interior environments and furnishing needs.; Designer: Antonio Citterio; Manufacturer: Vitra; Model: Suita Sofa 2-Seater - Without Headrest; OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/376133/storage/master/download/Factbook%20Suita2020-EN.pdf; Type Name: Suita Sofa 2-Seater - Without Headrest; URL: https://www.vitra.com/en-un/living/product/details/suita-sofa-2-seater-classic
Type - Materials and Finishes(Type) - SofaSecondaryMaterial: Aluminium polished 03
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Sofas; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Sofas_Vitra_Suita_Sofa_2seater; Features: Legs: die-cast aluminium, polished or powder-coated. Body: webbed metal frame with moulded polyurethane foam. Classic seat cushions, firm: polyurethane foam and polyester fibre. Armrest cushions: latex and siliconised fibres. Covers: removable. Glides: non-slip.; Finish: n/a; Grade: n/a; Material: Aluminium, polyurethane & leather; ModelNumber: n/a; ModelReference: n/a; Name: Vitra_Suita_Sofa_2seater; ReplacementCost: n/a; Shape: Sculptured; Size: 1880x880x885 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 3.93622 m2; Volume: 1.37812 m3
Materials and Finishes - SofaMainMaterial: Leather standard dimgrey 21
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Sofas_Vitra_Suita_Sofa_2seater: Suita Sofa 2-Seater - Without Headrest; Family and Type: Furniture_Sofas_Vitra_Suita_Sofa_2seater: Suita Sofa 2-Seater - Without Headrest; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Sofas_Vitra_Suita_Sofa_2seater: Suita Sofa 2-Seater - Without Headrest; Type Id: Furniture_Sofas_Vitra_Suita_Sofa_2seater: Suita Sofa 2-Seater - Without Headrest; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
